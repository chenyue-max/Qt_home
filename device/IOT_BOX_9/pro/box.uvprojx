# Keil uVision project box.uvprojx, settings and files
target box (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: box +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\devices;..\system;..\app;..\boot;..\hardware\BEEP;..\hardware\RGB_LED;..\hardware\WS2812B;..\hardware\CO2;..\hardware\debug-usart;..\hardware\USART3;..\hardware\TP4115;..\hardware\myiic;..\hardware\BH1750;..\hardware\SHT20;..\hardware\VML6070;..\hardware\SECURITY;..\hardware\PM2_5;..\hardware\SERVO;..\hardware\FAN;..\hardware\RELAY;..\hardware\A4988;..\hardware\LOCK;..\hardware\zigbee_usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c run.c
  group hardware
    ../hardware/BEEP/: beep.c
    ../hardware/RGB_LED/: rgb_led.c
    ../hardware/WS2812B/: ws2812b.c
    ../hardware/CO2/: CO2.c
    ../hardware/debug-usart/: Debug_usart.c
    ../hardware/USART3/: usart3.c
    ../hardware/TP4115/: tp4115.c
    ../hardware/myiic/: myiic.c
    ../hardware/BH1750/: bh1750.c
    ../hardware/SHT20/: sht20.c
    ../hardware/VML6070/: vml6070.c
    ../hardware/SECURITY/: security.c security5.c
    ../hardware/PM2_5/: pm2_5.c
    ../hardware/SERVO/: servo.c
    ../hardware/FAN/: fan.c
    ../hardware/RELAY/: relay.c
    ../hardware/A4988/: a4988.c
    ../hardware/LOCK/: lock.c
    ../hardware/zigbee_usart/: ZigBee_usart.c
  group system
    ../system/: core_cm3.c jpstm32_exti.c jpstm32_gpio.c jpstm32_nvic.c jpstm32_sysclk.c
  group device
    ../devices/: delay.c sys.c Tim.c Tim1.c
  group boot
    ../boot/: startup_stm32f10x_hd.s
