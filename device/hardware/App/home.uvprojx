# Keil uVision project home.uvprojx, settings and files
target home (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: home +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\devices;..\boot;..\system;..\App;..\hardware\zigbee_usart;..\hardware\WS2812B;..\hardware\TP4115;..\hardware\CO2;..\hardware\BH1750;..\hardware\USART3;..\hardware\SHT20;..\hardware\VEML6070;..\hardware\myiic;..\hardware\security;..\hardware\PM2.5;..\hardware\A4988;..\hardware\Fan;..\hardware\Lock;..\hardware\Relay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c function.c heart.c
  group hardware
    ../hardware/zigbee_usart/: ZigBee_usart.c
    ../hardware/WS2812B/: WS2812B.c
    ../hardware/TP4115/: TP4115.c
    ../hardware/BH1750/: BH1750.c
    ../hardware/SHT20/: SHT20.c
    ../hardware/CO2/: CO2.c
    ../hardware/USART3/: usart3.c
    ../hardware/VEML6070/: veml6070.c
    ../hardware/myiic/: myiic.c
    ../hardware/PM2.5/: PM2.5.c
    ../hardware/security/: security_windows.c security.c
    ../hardware/A4988/: A4988.c
    ../hardware/Fan/: fan.c
    ../hardware/Lock/: lock.c
    ../hardware/Relay/: Relay.c
  group system
    ../system/: core_cm3.c jpstm32_exti.c jpstm32_gpio.c jpstm32_nvic.c jpstm32_sysclk.c
  group device
    ../devices/: delay.c sys.c Tim.c Tim1.c
  group boot
    ../boot/: startup_stm32f10x_md.s
